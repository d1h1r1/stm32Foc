# Keil uVision project simplefoc_stm32f103.uvprojx, settings and files
target simplefoc_stm32f103 (6110000::V6.11::.\ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: simplefoc_stm32f103 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../SEGGER_RTT;../simplefoc/common;../simplefoc/common/base_classes;../components/DWT;../user;../simplefoc/sensors;../simplefoc/drivers;../simplefoc;../components/bsp_pwm;../simplefoc/current_sense
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: stmflash.c main.c gpio.c adc.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group SEGGER/RTT
    ../SEGGER_RTT/: SEGGER_RTT_printf.c SEGGER_RTT_Conf.h SEGGER_RTT.h SEGGER_RTT.c
  group simplefoc/common
    ../simplefoc/common/: defaults.h foc_utils.cpp lowpass_filter.cpp pid.cpp time_utils.cpp
  group simplefoc/basic_class
    ../simplefoc/common/base_classes/: BLDCDriver.h CurrentSense.cpp FOCMotor.cpp Sensor.cpp
  group simplefoc/sensors
    ../simplefoc/sensors/: AS5600_I2C.cpp AS5600_I2C.h
  group simplefoc/drivers
    ../simplefoc/drivers/: BLDCDriver3PWM.cpp
  group simplefoc/current_sense
    ../simplefoc/current_sense/: InlineCurrentSense.cpp
  group simplefoc
    ../simplefoc/: BLDCMotor.cpp
  group user
    ../user/: user_main.cpp
  group components
    ../components/DWT/: dwt_timer.c
    ../components/bsp_pwm/: bsp_pwm.c
target focSRAM (6110000::V6.11::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: simplefoc_stm32f103 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
  scatter file: .\RAMBOOT.SCT
software components: CMSIS:CORE 4.1.0
